options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: interp
  id: variable
  parameters:
    value: samp_rate/signal_freq
  states: {}
- name: rx_file
  id: variable
  parameters:
    value: '"/home/jhyoon/SpectrumChallenge/gnuradio_radar/Gnuradio_data/Rx/Rx"+waveform+".dat"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: signal_freq
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: tx_file
  id: variable
  parameters:
    value: '"/home/jhyoon/SpectrumChallenge/gnuradio_radar/Gnuradio_data/Tx/Tx"+waveform+".dat"'
  states: {}
- name: waveform
  id: variable
  parameters:
    value: '"Barker2"'
  states: {state: disabled}
- name: waveform
  id: variable
  parameters:
    value: '"LFM05"'
  states: {state: disabled}
- name: waveform
  id: variable
  parameters:
    value: '"Costas2_11"'
  states: {state: disabled}
- name: waveform
  id: variable
  parameters:
    value: '"Frank16"'
  states: {state: disabled}
- name: waveform
  id: variable
  parameters:
    value: '"P164"'
  states: {state: disabled}
- name: waveform
  id: variable
  parameters:
    value: '"T4_2_4"'
  states: {}
- name: Barker_waveform_0
  id: Barker_waveform
  parameters:
    code_length: '2'
    samp_rate: 2e6
  states: {state: disabled}
- name: Costas_waveform_1
  id: Costas_waveform
  parameters:
    prime_number: '11'
    primitive_root: '2'
    samp_rate: samp_rate
    seq_len: '1024'
  states: {state: disabled}
- name: LFMwaveform_0
  id: LFMwaveform
  parameters:
    amp: '1'
    offset: '0.5'
    samp_rate: samp_rate
  states: {state: disabled}
- name: Polytimewaveform_0
  id: Polytimewaveform
  parameters:
    Kind_of_signal: T4
    delta_f: '2000'
    interp: 2e6/500e3
    phase_state: '2'
    samp_rate: 2e6
    segment: '4'
    signal_freq: 2e6/4
    source_amplitude: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_throttle_1_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_1_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: capture_iq_0
  id: capture_iq
  parameters:
    file_path: tx_file
    samp_length: '2048'
    samp_length_skip: '2000'
  states: {}
- name: capture_iq_0_0
  id: capture_iq
  parameters:
    file_path: rx_file
    samp_length: '2048'
    samp_length_skip: '1000'
  states: {}
- name: polyphase_waveform_0
  id: polyphase_waveform
  parameters:
    code_length: '64'
    kind_of_signal: P1
    samp_freq: samp_rate/10
    samp_rate: samp_rate
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Rx"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Tx"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: usrp_tx_rx_0_0
  id: usrp_tx_rx
  parameters:
    center_freq: 910e6
    oversamp_multiply: '2'
    rx_gain: '15'
    rx_usrp_address: 166.104.231.198
    rx_usrp_antenna: RX2
    samp_rate: samp_rate
    tx_gain: '15'
    tx_usrp_address: 166.104.231.199
    tx_usrp_antenna: TX/RX
  states: {}

connections:
- [Barker_waveform_0, '0', blocks_throttle_1_1_1, '0']
- [Barker_waveform_0, '0', usrp_tx_rx_0_0, '0']
- [Costas_waveform_1, '0', blocks_throttle_1_1_1, '0']
- [Costas_waveform_1, '0', usrp_tx_rx_0_0, '0']
- [LFMwaveform_0, '0', blocks_throttle_1_1_1, '0']
- [LFMwaveform_0, '0', usrp_tx_rx_0_0, '0']
- [Polytimewaveform_0, '0', blocks_throttle_1_1_1, '0']
- [Polytimewaveform_0, '0', usrp_tx_rx_0_0, '0']
- [analog_sig_source_x_0, '0', qtgui_sink_x_0_0_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_skiphead_0, '0', capture_iq_0, '0']
- [blocks_throttle_1_1, '0', capture_iq_0_0, '0']
- [blocks_throttle_1_1, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_1_1_1, '0', blocks_skiphead_0, '0']
- [blocks_throttle_1_1_1, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle_1_1_1, '0', qtgui_sink_x_0_1, '0']
- [polyphase_waveform_0, '0', blocks_throttle_1_1_1, '0']
- [polyphase_waveform_0, '0', usrp_tx_rx_0_0, '0']
- [usrp_tx_rx_0_0, '0', blocks_throttle_1_1, '0']

metadata:
  file_format: 1
