options:
  parameters:
    category: '[Radar Waveform Blocks]'
    generate_options: hb
    id: LFMwaveform
    output_language: python
    title: LFM Waveform Block
  states: {}

blocks:
- name: amp
  id: parameter
  parameters:
    label: Amplitude
    type: eng_float
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: freq
    offset: offset
    phase: ''
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Freq_sqr
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: samp_rate*1.04
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Freq
    type: eng_float
    value: '0'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '500'
    win: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: offset
  id: parameter
  parameters:
    label: Offset
    type: eng_float
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: eng_float
    value: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_f_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', hilbert_fc_0, '0']
- [blocks_vco_f_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vco_f_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
