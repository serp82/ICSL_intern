options:
  parameters:
    generate_options: qt_gui
    id: test2
    output_language: python
    title: test
  states: {}

blocks:
- name: num
  id: variable
  parameters:
    value: ''
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_cf
  id: variable
  parameters:
    value: 905.5e6
  states: {}
- name: Barker_waveform_0
  id: Barker_waveform
  parameters:
    code_length: '13'
    samp_freq: samp_rate/20
    samp_rate: samp_rate
  states: {state: disabled}
- name: Barker_waveform_0_0
  id: Barker_waveform
  parameters:
    code_length: '13'
    samp_freq: samp_rate/20
    samp_rate: samp_rate
  states: {state: disabled}
- name: Barker_waveform_0_0_0
  id: Barker_waveform
  parameters:
    code_length: '7'
    samp_freq: samp_rate/40
    samp_rate: samp_rate
  states: {state: disabled}
- name: Barker_waveform_0_0_0_0
  id: Barker_waveform
  parameters:
    code_length: '13'
    samp_freq: samp_rate/20
    samp_rate: samp_rate
  states: {state: disabled}
- name: Costas_waveform_0
  id: Costas_waveform
  parameters:
    hopping_samp_len: '100'
    prime_number: '11'
    primitive_root: '2'
    samp_rate: samp_rate
  states: {}
- name: LFMwaveform_0
  id: LFMwaveform
  parameters:
    amp: '1'
    freq: samp_rate/500
    offset: '0'
    samp_rate: samp_rate
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/100
    offset: '0'
    phase: ''
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e4
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: samp_rate*1.04
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: 64*[1]+64*[0]
  states: {state: disabled}
- name: capture_iq_0
  id: capture_iq
  parameters:
    file_path: /home/jhyoon/SpectrumChallenge/gnuradio_radar/Gnuradio_data/test4.dat
    samp_length: '1000'
    samp_length_skip: '1000'
    seq_len: '100'
  states: {state: disabled}
- name: capture_iq_0_0
  id: capture_iq
  parameters:
    file_path: /home/jhyoon/SpectrumChallenge/gnuradio_radar/Gnuradio_data/test3.dat
    samp_length: '1000'
    samp_length_skip: '1000'
    seq_len: '100'
  states: {state: disabled}
- name: capture_iq_0_0_0
  id: capture_iq
  parameters:
    file_path: /home/jhyoon/SpectrumChallenge/gnuradio_radar/Gnuradio_data/test1.dat
    samp_length: '1000'
    samp_length_skip: '1000'
    seq_len: '100'
  states: {state: disabled}
- name: capture_iq_0_0_0_0
  id: capture_iq
  parameters:
    file_path: /home/jhyoon/SpectrumChallenge/gnuradio_radar/Gnuradio_data/test2.dat
    samp_length: '1000'
    samp_length_skip: '1000'
    seq_len: '100'
  states: {state: disabled}
- name: capture_iq_1
  id: capture_iq
  parameters:
    file_path: '''/home/jhyoon/SpectrumChallenge/gnuradio_radar/Gnuradio_data/Rx/RxLFM''+str(num)+''.dat'''
    samp_length: '1000'
    samp_length_skip: '1000'
    seq_len: '500'
  states: {state: disabled}
- name: capture_iq_1_0
  id: capture_iq
  parameters:
    file_path: '''/home/jhyoon/SpectrumChallenge/gnuradio_radar/Gnuradio_data/Tx/Txcostas4.dat'''
    samp_length: '1000'
    samp_length_skip: '1000'
    seq_len: '100'
  states: {}
- name: capture_iq_1_1
  id: capture_iq
  parameters:
    file_path: '''/home/jhyoon/SpectrumChallenge/gnuradio_radar/Gnuradio_data/Rx/origin/Rxcostas2_11_100.dat'''
    samp_length: '2000'
    samp_length_skip: '1000'
    seq_len: '500'
  states: {state: disabled}
- name: capture_iq_1_1_0
  id: capture_iq
  parameters:
    file_path: '''/home/jhyoon/SpectrumChallenge/gnuradio_radar/Gnuradio_data/Tx/origin/Txfrank16_12.dat'''
    samp_length: '2000'
    samp_length_skip: '1000'
    seq_len: '500'
  states: {state: disabled}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '100'
    win: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: polyphase_waveform_0
  id: polyphase_waveform
  parameters:
    code_length: '16'
    kind_of_signal: Frank
    samp_freq: 3.2e3
    samp_rate: 32e3
  states: {state: disabled}
- name: polyphase_waveform_1
  id: polyphase_waveform
  parameters:
    code_length: '16'
    kind_of_signal: Frank
    samp_freq: samp_rate/12
    samp_rate: samp_rate
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"500k"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"100k"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"100k"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"1"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"2"'
    rate: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"2"'
    rate: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"2"'
    rate: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"2"'
    rate: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"2"'
    rate: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0_0_1_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"2"'
    rate: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0_0_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"2"'
    rate: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"1"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: usrp_tx_rx_0
  id: usrp_tx_rx
  parameters:
    oversamp_multiply: '1'
    rx_center_freq: 910e6
    rx_gain: '18'
    rx_usrp_address: '''166.104.231.199'''
    rx_usrp_antenna: RX2
    samp_rate: samp_rate
    tx_center_freq: 910e6
    tx_gain: '18'
    tx_usrp_address: '''166.104.231.198'''
    tx_usrp_antenna: TX/RX
  states: {state: disabled}

connections:
- [Barker_waveform_0, '0', blocks_throttle_0, '0']
- [Barker_waveform_0, '0', capture_iq_1_1_0, '0']
- [Barker_waveform_0, '0', qtgui_sink_x_0_0_0_0_0_0_0_0, '0']
- [Barker_waveform_0, '0', qtgui_sink_x_0_0_0_0_0_0_2, '0']
- [Barker_waveform_0_0, '0', blocks_multiply_xx_0_0, '0']
- [Barker_waveform_0_0, '0', capture_iq_0_0, '0']
- [Barker_waveform_0_0, '0', qtgui_sink_x_0_0_0_0_0, '0']
- [Barker_waveform_0_0_0, '0', capture_iq_0_0_0, '0']
- [Barker_waveform_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [Barker_waveform_0_0_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [Barker_waveform_0_0_0_0, '0', capture_iq_0_0_0_0, '0']
- [Barker_waveform_0_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [Barker_waveform_0_0_0_0, '0', qtgui_sink_x_1, '0']
- [Costas_waveform_0, '0', capture_iq_1_0, '0']
- [Costas_waveform_0, '0', qtgui_sink_x_0_0_0_0_0_0_2, '0']

metadata:
  file_format: 1
